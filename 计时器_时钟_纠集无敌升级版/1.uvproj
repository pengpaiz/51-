# Keil uVision project 1.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: 1 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: 1.c timer0.c timer0.h Delay.c Delay.h LCD1602.c LCD1602.h key_jvzheng.c key_jvzheng.h
    ../计时器_时钟/: DULIKEY.c DULIKEY.h
